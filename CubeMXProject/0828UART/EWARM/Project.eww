<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\0828I2C\EWARM\0828I2C.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\0828UART.ewp</path>
    </project>
    <batchBuild />
</workspace>
