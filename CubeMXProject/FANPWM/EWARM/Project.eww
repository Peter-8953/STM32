<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FANPWM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\I2C_INA228\EWARM\I2C_INA228.ewp</path>
    </project>
    <batchBuild />
</workspace>
